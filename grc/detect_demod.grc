options:
  parameters:
    author: jbonior
    category: '[RWT Tools]'
    copyright: Red Wire Technologies
    generate_options: hb
    id: detect_demod
    output_language: python
    title: Detect and Demodulate
  states: {}

blocks:
- name: FreqDev
  id: parameter
  parameters:
    label: Frequency Deviation
    value: 29e3
  states: {}
- name: Preamble
  id: parameter
  parameters:
    label: Preamble Sequence
    value: np.tile([0, 1, 0, 1, 0, 1, 0, 1], 24)
  states: {}
- name: SampleRate
  id: parameter
  parameters:
    label: Sample Rate
    value: 2e6
  states: {}
- name: SymbolRate
  id: parameter
  parameters:
    label: Symbol Rate
    value: 100e3
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: SampleRate/(2*np.pi*FreqDev/8)
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_1_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1,1]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: samples_out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: corr_out
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rwt_tools_ook_preamble_correlator_0
  id: rwt_tools_ook_preamble_correlator
  parameters:
    preamble: Preamble
    sampleRate: int(SampleRate)
    symbolRate: int(SymbolRate)
    threshold: 1/(len(Preamble)*SampleRate/SymbolRate)*0.70
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', digital_chunks_to_symbols_xx_1_0, '0']
- [digital_chunks_to_symbols_xx_1_0, '0', rwt_tools_ook_preamble_correlator_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [rwt_tools_ook_preamble_correlator_0, '0', pad_sink_0, '0']
- [rwt_tools_ook_preamble_correlator_0, '1', pad_sink_1, '0']

metadata:
  file_format: 1
